Commit message: update

File: xarm_description/compiled/lite6_normal_gripper.urdf (robot description, URDF)
Before this commit: robot lite6_gripper, 2 links, 2 joints
Joints:
- removed joint gripper_fix
